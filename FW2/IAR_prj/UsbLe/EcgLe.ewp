# IAR project EcgLe.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ECG; DEBUG; BOARD_PCA10059; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_SD_BLE_API_VERSION=6; S140; SOFTDEVICE_PRESENT; SWI_DISABLE0; CONFIG_NFCT_PINS_AS_GPIOS
  ICCARM.CCIncludePath2: ; ..\Boards\pca10056_UsbLe; ..\MyNordic; ..\AppProcesses; ..\DsCommons; ..\..\NordicSource\components; ..\..\NordicSource\components\ble\ble_advertising; ..\..\NordicSource\components\ble\ble_dtm; ..\..\NordicSource\components\ble\ble_link_ctx_manager; ..\..\NordicSource\components\ble\ble_racp; ..\..\NordicSource\components\ble\ble_services\ble_ancs_c; ..\..\NordicSource\components\ble\ble_services\ble_ans_c; ..\..\NordicSource\components\ble\ble_services\ble_bas; ..\..\NordicSource\components\ble\ble_services\ble_bas_c; ..\..\NordicSource\components\ble\ble_services\ble_cscs; ..\..\NordicSource\components\ble\ble_services\ble_cts_c; ..\..\NordicSource\components\ble\ble_services\ble_dfu; ..\..\NordicSource\components\ble\ble_services\ble_dis; ..\..\NordicSource\components\ble\ble_services\ble_gls; ..\..\NordicSource\components\ble\ble_services\ble_hids; ..\..\NordicSource\components\ble\ble_services\ble_hrs; ..\..\NordicSource\components\ble\ble_services\ble_hrs_c; ..\..\NordicSource\components\ble\ble_services\ble_hts; ..\..\NordicSource\components\ble\ble_services\ble_ias; ..\..\NordicSource\components\ble\ble_services\ble_ias_c; ..\..\NordicSource\components\ble\ble_services\ble_lbs; ..\..\NordicSource\components\ble\ble_services\ble_lbs_c; ..\..\NordicSource\components\ble\ble_services\ble_lls; ..\..\NordicSource\components\ble\ble_services\ble_nus; ..\..\NordicSource\components\ble\ble_services\ble_nus_c; ..\..\NordicSource\components\ble\ble_services\ble_rscs; ..\..\NordicSource\components\ble\ble_services\ble_rscs_c; ..\..\NordicSource\components\ble\ble_services\ble_tps; ..\..\NordicSource\components\ble\common; ..\..\NordicSource\components\ble\nrf_ble_gatt; ..\..\NordicSource\components\ble\nrf_ble_qwr; ..\..\NordicSource\components\ble\peer_manager; ..\..\NordicSource\components\boards; ..\..\NordicSource\components\drivers_nrf\usbd; ..\..\NordicSource\components\libraries\atomic; ..\..\NordicSource\components\libraries\atomic_fifo; ..\..\NordicSource\components\libraries\atomic_flags; ..\..\NordicSource\components\libraries\balloc; ..\..\NordicSource\components\libraries\bootloader\ble_dfu; ..\..\NordicSource\components\libraries\bsp; ..\..\NordicSource\components\libraries\button; ..\..\NordicSource\components\libraries\cli; ..\..\NordicSource\components\libraries\crc16; ..\..\NordicSource\components\libraries\crc32; ..\..\NordicSource\components\libraries\crypto; ..\..\NordicSource\components\libraries\csense; ..\..\NordicSource\components\libraries\csense_drv; ..\..\NordicSource\components\libraries\delay; ..\..\NordicSource\components\libraries\ecc; ..\..\NordicSource\components\libraries\experimental_section_vars; ..\..\NordicSource\components\libraries\experimental_task_manager; ..\..\NordicSource\components\libraries\fds; ..\..\NordicSource\components\libraries\fifo; ..\..\NordicSource\components\libraries\fstorage; ..\..\NordicSource\components\libraries\gfx; ..\..\NordicSource\components\libraries\gpiote; ..\..\NordicSource\components\libraries\hardfault; ..\..\NordicSource\components\libraries\hardfault\nrf52; ..\..\NordicSource\components\libraries\hci; ..\..\NordicSource\components\libraries\led_softblink; ..\..\NordicSource\components\libraries\log; ..\..\NordicSource\components\libraries\log\src; ..\..\NordicSource\components\libraries\low_power_pwm; ..\..\NordicSource\components\libraries\mem_manager; ..\..\NordicSource\components\libraries\memobj; ..\..\NordicSource\components\libraries\mpu; ..\..\NordicSource\components\libraries\mutex; ..\..\NordicSource\components\libraries\pwm; ..\..\NordicSource\components\libraries\pwr_mgmt; ..\..\NordicSource\components\libraries\queue; ..\..\NordicSource\components\libraries\ringbuf; ..\..\NordicSource\components\libraries\scheduler; ..\..\NordicSource\components\libraries\sdcard; ..\..\NordicSource\components\libraries\slip; ..\..\NordicSource\components\libraries\sortlist; ..\..\NordicSource\components\libraries\spi_mngr; ..\..\NordicSource\components\libraries\stack_guard; ..\..\NordicSource\components\libraries\strerror; ..\..\NordicSource\components\libraries\svc; ..\..\NordicSource\components\libraries\timer; ..\..\NordicSource\components\libraries\twi_mngr; ..\..\NordicSource\components\libraries\twi_sensor; ..\..\NordicSource\components\libraries\uart; ..\..\NordicSource\components\libraries\usbd; ..\..\NordicSource\components\libraries\usbd\class\audio; ..\..\NordicSource\components\libraries\usbd\class\cdc; ..\..\NordicSource\components\libraries\usbd\class\cdc\acm; ..\..\NordicSource\components\libraries\usbd\class\hid; ..\..\NordicSource\components\libraries\usbd\class\hid\generic; ..\..\NordicSource\components\libraries\usbd\class\hid\kbd; ..\..\NordicSource\components\libraries\usbd\class\hid\mouse; ..\..\NordicSource\components\libraries\usbd\class\msc; ..\..\NordicSource\components\libraries\util; ..\..\NordicSource\components\nfc\ndef\conn_hand_parser; ..\..\NordicSource\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\NordicSource\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\NordicSource\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\NordicSource\components\nfc\ndef\connection_handover\ac_rec; ..\..\NordicSource\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\NordicSource\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\NordicSource\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\NordicSource\components\nfc\ndef\connection_handover\common; ..\..\NordicSource\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\NordicSource\components\nfc\ndef\connection_handover\hs_rec; ..\..\NordicSource\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\NordicSource\components\nfc\ndef\generic\message; ..\..\NordicSource\components\nfc\ndef\generic\record; ..\..\NordicSource\components\nfc\ndef\launchapp; ..\..\NordicSource\components\nfc\ndef\parser\message; ..\..\NordicSource\components\nfc\ndef\parser\record; ..\..\NordicSource\components\nfc\ndef\text; ..\..\NordicSource\components\nfc\ndef\uri; ..\..\NordicSource\components\nfc\t2t_lib; ..\..\NordicSource\components\nfc\t2t_lib\hal_t2t; ..\..\NordicSource\components\nfc\t2t_parser; ..\..\NordicSource\components\nfc\t4t_lib; ..\..\NordicSource\components\nfc\t4t_lib\hal_t4t; ..\..\NordicSource\components\nfc\t4t_parser\apdu; ..\..\NordicSource\components\nfc\t4t_parser\cc_file; ..\..\NordicSource\components\nfc\t4t_parser\hl_detection_procedure; ..\..\NordicSource\components\nfc\t4t_parser\tlv; ..\..\NordicSource\components\softdevice\common; ..\..\NordicSource\components\softdevice\s140\headers; ..\..\NordicSource\components\softdevice\s140\headers\nrf52; ..\..\NordicSource\components\toolchain\cmsis\include; ..\..\NordicSource\external\fprintf; ..\..\NordicSource\external\segger_rtt; ..\..\NordicSource\external\utf_converter; ..\..\NordicSource\integration\nrfx; ..\..\NordicSource\integration\nrfx\legacy; ..\..\NordicSource\modules\nrfx; ..\..\NordicSource\modules\nrfx\drivers\include; ..\..\NordicSource\modules\nrfx\hal; ..\..\NordicSource\modules\nrfx\mdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EcgLe.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: SpiroLe.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration nrf52840_xxaa (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ./: main.c
    ../Boards/pca10056_UsbLe/: sdk_config.h
  group Application/ecg_sensor
    ../ecg_sensor/: ecg_adc.c ecg_sensor.h
  group Application/ecg_sensor/ads129x
    ../ecg_sensor/ads129x/: ads129x.c
  group Application/Processes
    ../AppProcesses/: ecg_process.c host_interfase.c
  group Application/twi_sensor
    ../twi_sensor/: acc_sensor.c
  group Board Definition
    ../../NordicSource/components/boards/: boards.c
    ../Boards/pca10056_UsbLe/: ecg_pin_config.c
  group Board Support
    ../../NordicSource/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group DsCommons
    ../DsCommons/: bit_operations.cpp compressor.cpp crc16_ccitt.cpp filter_ac.cpp filter_dc_remove.cpp net_level.cpp types_porting.cpp
  group MyNordic
    ../MyNordic/: flash_mem.c timestamp_timer.c
  group None
    ../../NordicSource/modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_BLE
    ../../NordicSource/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../NordicSource/components/ble/ble_advertising/: ble_advertising.c
    ../../NordicSource/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../NordicSource/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../NordicSource/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../NordicSource/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_spi.c nrf_drv_twi.c nrf_drv_uart.c
    ../../NordicSource/components/drivers_nrf/usbd/: nrf_drv_usbd.c
    ../../NordicSource/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_power_clock.c nrfx_spim.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c
    ../../NordicSource/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../NordicSource/components/libraries/button/: app_button.c
    ../../NordicSource/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../NordicSource/components/libraries/fifo/: app_fifo.c
    ../../NordicSource/components/libraries/scheduler/: app_scheduler.c
    ../../NordicSource/components/libraries/timer/: app_timer.c
    ../../NordicSource/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../NordicSource/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../NordicSource/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../NordicSource/components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../NordicSource/components/libraries/hardfault/: hardfault_implementation.c
    ../../NordicSource/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../NordicSource/components/libraries/atomic_flags/: nrf_atflags.c
    ../../NordicSource/components/libraries/atomic/: nrf_atomic.c
    ../../NordicSource/components/libraries/balloc/: nrf_balloc.c
    ../../NordicSource/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../NordicSource/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../NordicSource/components/libraries/memobj/: nrf_memobj.c
    ../../NordicSource/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../NordicSource/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../NordicSource/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../NordicSource/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../NordicSource/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../NordicSource/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../NordicSource/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group UTF8/UTF16 converter
    ../../NordicSource/external/utf_converter/: utf.c
