<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EcgLe.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SpiroLe.ewp</path>
  </project>
  <batchBuild/>
</workspace>


